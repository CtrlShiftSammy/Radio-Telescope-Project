options:
  parameters:
    generate_options: qt_gui
    id: FFT_Plot
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bandpass_bandwidth
  id: variable
  parameters:
    value: 80e6
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 1.45E9
  states: {}
- name: channel_width
  id: variable
  parameters:
    value: 200E3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2E6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    beta: '6.76'
    decim: '1'
    gain: '1'
    high_cutoff_freq: (bandpass_bandwidth / 2)
    low_cutoff_freq: (bandpass_bandwidth / 2)
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1'
    win: window.WIN_KAISER
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
