options:
  parameters:
    generate_options: qt_gui
    id: Radiometer
    output_language: python
    title: Radiometer
  states: {}

blocks:
- name: P_cold
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,2,1,1]'
    label: Cold Pw
    type: real
    value: '110'
  states: {}
- name: P_hot
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,3,1,1]'
    label: Hot Pw
    type: real
    value: '287'
  states: {}
- name: Save_CSV_File
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,2,1,1]'
    label: Save To CSV File
    label0: Stop Save To File
    label1: Start Save To File
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: T_cold
  id: variable
  parameters:
    value: '10'
  states: {}
- name: T_hot
  id: variable
  parameters:
    value: '300'
  states: {}
- name: T_sys
  id: variable
  parameters:
    value: (T_hot - T_cold*(P_hot/P_cold))/((P_hot/P_cold) - 1)
  states: {}
- name: Tsys_label
  id: variable_qtgui_label
  parameters:
    gui_hint: '[3,5,1,1]'
    label: Tsys
    type: real
    value: T_sys
  states: {}
- name: az
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: calibration_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,1,1,1]'
    label: Select Calibration
    label0: Without Calibration
    label1: With Calibration
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: csvfile
  id: variable
  parameters:
    value: prefix + timenow +"_AZ"+az+"_EL"+el +".csv"
  states: {}
- name: dc_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,1,1,1]'
    label: DC Gain
    type: int
    value: '10000'
  states: {}
- name: el
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: file_rate
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1420e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: (P_hot-P_cold)/(T_hot-T_cold)
  states: {}
- name: gain_label
  id: variable_qtgui_label
  parameters:
    gui_hint: '[2,5,1,1]'
    label: Gain
    type: real
    value: gain
  states: {}
- name: integrationTimeLong
  id: variable
  parameters:
    value: '1'
  states: {}
- name: integrationTimeShort
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: integration_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,0,1,1]'
    label: Integration Time
    label0: Short Integration
    label1: Long Integration
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: intermediate_rate
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"/run/media/sammy/Projects/Radio-Telescope-Project/Analysis/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: timenow
  id: variable
  parameters:
    value: datetime.now().strftime("%Y-%m-%d_%H.%M.%S")
  states: {}
- name: ymax
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: y-axis max
    min_len: '5'
    start: '0'
    step: '10'
    stop: '10000'
    value: '200'
    widget: counter
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-T_sys'
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(intermediate_rate/file_rate)
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/intermediate_rate)
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dc_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/gain
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: integration_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: calibration_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: Save_CSV_File
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: airspy=0,bias=0,pack=0
    bb_gain0: '10'
    freq0: freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {state: disabled}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    gui_hint: '[0,4,2,2]'
    label1: Histogram
    name: '"System Hearbeat"'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: '[2,4,1,1]'
    label1: Value
    min: '0'
    name: '"Radiometer"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: '[2,0,3,4]'
    label1: Signal
    size: '1024'
    srate: intermediate_rate
    type: float
    update_time: '0.1'
    ylabel: Total Power
    ymax: ymax
  states: {}
- name: radiometer_csv_file_writer_0
  id: radiometer_csv_file_writer
  parameters:
    az: az
    el: el
    prefix: prefix
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1/(samp_rate*integrationTimeShort)
    type: float
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1/(samp_rate*integrationTimeLong)
    type: float
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_selector_0_0, '1']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_selector_0_0_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_selector_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_selector_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_selector_0_0, '0', qtgui_number_sink_0, '0']
- [blocks_selector_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0_0_0, '1', radiometer_csv_file_writer_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_selector_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
