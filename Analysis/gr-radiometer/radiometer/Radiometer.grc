options:
  parameters:
    generate_options: qt_gui
    id: Radiometer
    output_language: python
    title: Radiometer
  states: {}

blocks:
- name: Save_CSV_File
  id: variable_qtgui_chooser
  parameters:
    gui_hint: '[0,2,1,1]'
    label: Save To CSV File
    label0: Stop
    label1: Start
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: az
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: csv_prefix
  id: variable
  parameters:
    value: directory + reading + time0+"_"
  states: {}
- name: csvfile
  id: variable
  parameters:
    value: prefix + timenow +".csv"
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%d-%m-%Y")
  states: {}
- name: dc_gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: '[1,1,1,1]'
    label: DC Gain
    type: int
    value: '10000'
  states: {}
- name: directory
  id: variable
  parameters:
    value: '"/run/media/sammy/Projects/Radio-Telescope-Project/"'
  states: {}
- name: display_time
  id: variable
  parameters:
    value: '60'
  states: {}
- name: el
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: file_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1440e6
  states: {}
- name: integration_time
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '10'
    value: '5'
  states: {}
- name: intermediate_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: directory + reading
  states: {}
- name: reading
  id: variable
  parameters:
    value: '"Readings/ASRT/" + date + "/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: time0
  id: variable
  parameters:
    value: datetime.now().strftime("%H:%M:%S")
  states: {}
- name: timenow
  id: variable
  parameters:
    value: datetime.now().strftime("%Y-%m-%d_%H.%M.%S")
  states: {}
- name: ymax
  id: variable_qtgui_range
  parameters:
    gui_hint: '[1,0,1,1]'
    label: y-axis max
    min_len: '5'
    start: '0'
    step: '10'
    stop: '10000'
    value: '200'
    widget: counter
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(intermediate_rate/file_rate)
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/intermediate_rate)
    type: float
  states: {state: disabled}
- name: blocks_keep_one_in_n_1_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/intermediate_rate)
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '1000'
    scale: 1/1000
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dc_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dc_gain
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dc_gain
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: Save_CSV_File
    type: float
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: '[2,4,1,1]'
    label1: Value
    min: '0'
    name: '"Radiometer"'
    type: float
  states: {state: disabled}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 2.4e6
    fc: '1450000000'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    label1: Signal
    size: intermediate_rate*60
    srate: intermediate_rate
    type: float
    update_time: '0.1'
    ylabel: Total Power
    ymax: ymax
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    label1: Signal
    size: int(intermediate_rate/20)
    srate: intermediate_rate
    type: float
    update_time: '0.01'
    ylabel: RTL-SDR Source
    ymax: ymax
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    label1: Signal
    size: int(intermediate_rate/20)
    srate: intermediate_rate
    type: float
    update_time: '0.1'
    ylabel: Low-Pass Filter
    ymax: ymax
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    label1: Signal
    size: file_rate*5
    srate: file_rate
    type: float
    update_time: '0.1'
    ylabel: File Data
    ymax: ymax
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: 2.5e9
    fc: freq
    fftsize: '32768'
    grid: 'True'
    type: complex
  states: {}
- name: radiometer_csv_file_writer_0
  id: radiometer_csv_file_writer
  parameters:
    az: az
    el: el
    prefix: csv_prefix
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 100e6
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1/(samp_rate*integration_time)
    type: float
  states: {state: disabled}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_1, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_keep_one_in_n_1_0, '0']
- [blocks_complex_to_mag_squared_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_selector_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_keep_one_in_n_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_keep_one_in_n_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_selector_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0_0_0, '1', radiometer_csv_file_writer_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_keep_one_in_n_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
