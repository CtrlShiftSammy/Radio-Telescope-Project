options:
  parameters:
    generate_options: qt_gui
    id: Radiometer
    output_language: python
    title: Radiometer
  states: {}

blocks:
- name: BB_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: BB Gain
    start: '0'
    step: '0.1'
    stop: '30'
    value: '25'
  states: {}
- name: IF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: IF Gain
    start: '0'
    step: '0.1'
    stop: '30'
    value: '20'
  states: {}
- name: RF_Gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: RF Gain
    start: '0'
    step: '0.1'
    stop: '30'
    value: '5'
  states: {}
- name: Save_CSV_File
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 6,0,1,1
    label: Save To CSV File
    label0: Stop
    label1: Start
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: real
    value: '0'
    widget: radio_buttons
  states: {}
- name: az
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,0,1,1
    start: 1e6
    step: 1e6
    stop: 100e6
    value: 50e6
  states: {}
- name: date
  id: variable
  parameters:
    value: datetime.now().strftime("%d-%m-%Y")
  states: {}
- name: dc_gain
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: directory
  id: variable
  parameters:
    value: '"/run/media/sammy/Projects/Radio-Telescope-Project/"'
  states: {}
- name: el
  id: variable
  parameters:
    value: '"0"'
  states: {}
- name: file_name
  id: variable
  parameters:
    value: directory + reading + time0+"_Raw.dat"
  states: {}
- name: file_rate
  id: variable
  parameters:
    value: '10'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    start: 950e6
    step: 1e6
    stop: 1950e6
    value: 1449e6
  states: {}
- name: integration_time
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0.1'
  states: {}
- name: intermediate_rate
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: directory + reading
  states: {}
- name: processed_csv_prefix
  id: variable
  parameters:
    value: directory + reading + time0+"_Processed_"
  states: {}
- name: reading
  id: variable
  parameters:
    value: '"Readings/ASRT/" + date + "/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: time0
  id: variable
  parameters:
    value: datetime.now().strftime("%H:%M:%S")
  states: {}
- name: timenow
  id: variable
  parameters:
    value: datetime.now().strftime("%Y-%m-%d_%H.%M.%S")
  states: {}
- name: ymax
  id: variable
  parameters:
    value: '200'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: file_name
    type: complex
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(intermediate_rate/file_rate)
    type: float
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/intermediate_rate)
    type: complex
  states: {}
- name: blocks_moving_average_xx_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '1000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: dc_gain
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: Save_CSV_File
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from datetime import datetime
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: 4*bandwidth
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,1,8,1
    legend: 'False'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 7,0,1,1
    label1: Value
    min: '0'
    name: '"Radiometer"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 8,0,1,1
    label1: Signal
    legend: 'False'
    size: intermediate_rate*20
    srate: intermediate_rate
    type: float
    update_time: '0.1'
    ylabel: Averaged Power
    ymax: ymax
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    gui_hint: 9,0,1,1
    label1: Signal
    legend: 'False'
    size: file_rate*20
    srate: file_rate
    type: float
    update_time: '0.1'
    ylabel: Processed Power
    ymax: ymax
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: bandwidth
    fc: freq
    fftsize: '2048'
    gui_hint: 8,1,3,1
    type: complex
  states: {}
- name: radiometer_csv_file_writer_0
  id: radiometer_csv_file_writer
  parameters:
    az: az
    el: el
    prefix: processed_csv_prefix
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: BB_Gain
    bw0: bandwidth
    freq0: freq
    gain0: RF_Gain
    gain_mode0: 'False'
    if_gain0: IF_Gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1/(samp_rate*integration_time)
    type: float
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_selector_0_0_0, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [blocks_keep_one_in_n_1, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_keep_one_in_n_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_moving_average_xx_0_1, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_moving_average_xx_0_1, '0', single_pole_iir_filter_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0_1, '0']
- [blocks_selector_0_0_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0_0_0, '1', radiometer_csv_file_writer_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_keep_one_in_n_1, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [single_pole_iir_filter_xx_0_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
