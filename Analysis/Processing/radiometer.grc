options:
  parameters:
    generate_options: qt_gui
    id: radiometer
    output_language: python
    title: Radiometer
  states: {}

blocks:
- name: csvfile
  id: variable
  parameters:
    value: prefix + timenow +"_AZ"+az+"_EL"+el +".csv"
  states: {}
- name: frequency
  id: variable
  parameters:
    value: 1.45E9
  states: {}
- name: integration_select
  id: variable_qtgui_chooser
  parameters:
    label0: 0.5 s
    label1: 2 s
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: prefix
  id: variable
  parameters:
    value: '"/run/media/sammy/Projects/Radio-Telescope-Project/Analysis/"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5E6
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    type: complex
  states: {}
- name: blocks_keep_one_in_n_1
  id: blocks_keep_one_in_n
  parameters:
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: integration_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '1024'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: radiometer_csv_file_writer_0
  id: radiometer_csv_file_writer
  parameters:
    az: ''
    el: ''
    prefix: ''
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '10'
    freq0: frequency
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0 / (samp_rate * 2)
    type: complex
  states: {}
- name: single_pole_iir_filter_xx_1
  id: single_pole_iir_filter_xx
  parameters:
    alpha: 1.0 / (samp_rate * 0.5)
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_float_1, '0', radiometer_csv_file_writer_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_1, '0']
- [blocks_complex_to_real_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', single_pole_iir_filter_xx_0, '0']
- [blocks_float_to_complex_1, '0', single_pole_iir_filter_xx_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_keep_one_in_n_1, '0', blocks_complex_to_float_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_keep_one_in_n_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0, '0', blocks_keep_one_in_n_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_selector_0, '0']
- [single_pole_iir_filter_xx_1, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
